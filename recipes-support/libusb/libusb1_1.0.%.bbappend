DEPENDS_append = " udev"

EXTRA_OECONF = "--libdir=${base_libdir} --enable-udev"
