include cgminer_git.bb

PACKAGECONFIG_append += " hashfast"
