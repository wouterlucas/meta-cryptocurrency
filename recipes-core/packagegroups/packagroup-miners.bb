DESCRIPTION = "Miners packageroup"
LICENSE = "MIT"

inherit packagegroup

PACKAGES = "\
    packagegroup-miners \
"

RDEPENDS_packagegroup-miners = "\
    cgminer-gekko \
    cpuminer-multi \
"
