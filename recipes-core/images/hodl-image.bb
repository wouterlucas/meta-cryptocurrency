DESCRIPTION = "Cryptocurrency Miner/Wallet image for RaspberryPI"
LICENSE = "MIT"

include hodl.inc
