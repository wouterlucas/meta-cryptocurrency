include cgminer_git.bb

PACKAGECONFIG_append += " bitmine_A1"
